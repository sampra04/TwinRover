Commit message: Fixed LiDAR reading robot, tilt, and scan odom

File: src/twinrover_gazebo/urdf/my_robot.urdf (robot description, URDF)
Before this commit: robot my_robot, 6 links, 5 joints
Joints:
- joint lidar_joint: origin xyz=0 0 0.1905 -> xyz=0 0 0.22
